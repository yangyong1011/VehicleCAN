# Keil uVision project Project.uvproj, settings and files
target STM32100E-EVAL (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM32100E-EVAL +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c include: ..\;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\source;..\source\os;..\source\app;..\source\app\led;..\source\lib
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../: stm32f10x_it.c main.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c misc.c
  group CMSIS
    ../: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group MDK-ARM
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group Doc
    ./: readme.txt
  group source
    ../source/os/: os.c os_timer.c
    ../source/app/led/: led.c
target STM3210E-EVAL_XL (ARM-ADS)
  device: STM32F103ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210E-EVAL_XL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_XL, USE_STM3210E_EVAL
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\STM3210E_EVAL;..\..\..\Utilities\STM32_EVAL\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
target STM32100B-EVAL (ARM-ADS)
  device: STM32F100VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32100B-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD_VL, USE_STM32100B_EVAL
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM32100B_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
target STM3210C-EVAL (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: STM3210C-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL, USE_STM3210C_EVAL
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target STM3210E-EVAL (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210E-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210E_EVAL
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM3210E_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target STM3210B-EVAL (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210B-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM3210B_EVAL
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\STM3210B_EVAL;..\..\..\Utilities\STM32_EVAL\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
